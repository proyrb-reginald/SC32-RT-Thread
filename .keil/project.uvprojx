# Keil uVision project project.uvprojx, settings and files
target Main (6230000::V6.23::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 v6Lto=1 wLevel=3
  c define: SC32R803
  c include: ..\.cmsis\inc;..\hal\SC32F1X\inc;..\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group .cmsis/dev
    ../.cmsis/dev/: startup_sc32r803.s
  group hal/SC32F1X/src/
    ../hal/SC32F1X/src/: sc32f1xxx_adc.c sc32f1xxx_btm.c sc32f1xxx_can.c sc32f1xxx_cmp.c sc32f1xxx_crc.c sc32f1xxx_dac.c sc32f1xxx_dma.c sc32f1xxx_gpio.c sc32f1xxx_iap.c sc32f1xxx_int.c sc32f1xxx_lcd.c sc32f1xxx_led.c sc32f1xxx_ledpwm.c sc32f1xxx_op.c sc32f1xxx_option.c sc32f1xxx_pga.c sc32f1xxx_pwm.c sc32f1xxx_pwr.c sc32f1xxx_qep.c sc32f1xxx_qspi.c sc32f1xxx_rcc.c sc32f1xxx_spi.c sc32f1xxx_spi1_twi1.c sc32f1xxx_temper.c sc32f1xxx_tim.c sc32f1xxx_twi.c sc32f1xxx_uart.c sc32f1xxx_vref.c sc32f1xxx_wdt.c system_sc32f1xxx.c
  group src/
    ../src/: main.c
